# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: RVDS_ARMCM4_NUC505
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_nuc505series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/SOURCE/: tasks.c timers.c list.c queue.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/SOURCE/portable/MemMang/: heap_2.c
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/DEMO/COMMON/Minimal/: QueueSet.c flash.c PollQ.c
