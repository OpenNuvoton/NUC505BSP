# Keil uVision project I2S_NAU8822_MP3PLAYER_SD.uvprojx, settings and files
target I2S_NAU8822_MP3PLAYER_SD (6120000::V6.12::.\ARMCLANG)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_NAU8822_MP3PLAYER_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __WINS__ OPT_SPEED
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\ThirdParty\libmad\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FATFS\src
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\spirom_SD.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../: startup_NUC505Series.s
  group Source
    ../: main.c diskio.c SDGlue.c mp3.c MP3HeaderParser.c nuc505_isr.c ExternalCODEC.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c clk.c uart.c retarget.c sd.c i2c.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group MP3Lib
    ../../../../ThirdParty/libmad/src/: version.c bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c MP3Func.c stream.c synth.c timer.c
