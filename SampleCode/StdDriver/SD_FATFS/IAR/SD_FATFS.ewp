# IAR project SD_FATFS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\ThirdParty\FATFS\src; ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SD_FATFS.bin
  ILINK.IlinkOutputFile: SD_FATFS.out
  ILINK.IlinkIcfFile: spirom.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/IAR/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sd.c sys.c timer.c uart.c
  group User
    ../: diskio.c main.c SDGlue.c
