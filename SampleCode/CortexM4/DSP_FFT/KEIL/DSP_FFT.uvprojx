# Keil uVision project DSP_FFT.uvprojx, settings and files
target DSP_FFT (6120000::V6.12::.\ARMCLANG)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: DSP_FFT
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\CMSIS\DSP\PrivateInclude;..\..\..\..\Library\CMSIS\DSP\Source\SupportFunctions;..\..\..\..\Library\CMSIS\DSP\Source\TransformFunctions;..\..\..\..\Library\CMSIS\DSP\Source\StatisticsFunctions;..\..\..\..\Library\CMSIS\DSP\Source\ComplexMathFunctions;..\..\..\..\Library\CMSIS\DSP\Source\CommonTables
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_NUC505Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c sys.c
  group User
    ../: main.c arm_fft_bin_data.c DSP_Functions.c
