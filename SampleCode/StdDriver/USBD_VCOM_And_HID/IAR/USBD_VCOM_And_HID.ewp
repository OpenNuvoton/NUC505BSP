# IAR project USBD_VCOM_And_HID.ewp, settings and files
configuration Mouse (ARM)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __VCOM_MOUSE__
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_VCOM_And_HID.bin
  ILINK.IlinkOutputFile: USBD_VCOM_And_HID.out
  ILINK.IlinkIcfFile: spirom.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Keyboard (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __VCOM_KEYBOARD__
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/IAR/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c
  group User
    ../: descriptors.c main.c vcom_serial.c
