# IAR project DSP_FFT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4=1; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DSP_FFT.bin
  ILINK.IlinkOutputFile: DSP_FFT.out
  ILINK.IlinkIcfFile: sram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Library\CMSIS\Lib\ARM\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/IAR/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../../../Library/CMSIS/DSP_Lib/Examples/arm_fft_bin_example/ARM/: arm_fft_bin_data.c
    ../: main.c
