# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6120000::V6.12::.\ARMCLANG)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: RVDS_ARMCM4_NUC505
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_nuc505series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group System
    ../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c flash.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
