# IAR project USBD_Audio_Headset.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pa182
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\Audio; ..\Hardware; ..\USB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio_Headset.bin
  ILINK.IlinkOutputFile: USBD_Audio_Headset.out
  ILINK.IlinkIcfFile: main_on_sram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Audio
    ../Audio/: AudioLib.c AudioLib_Play.c AudioLib_Play16.c AudioLib_Play16_2.c AudioLib_Play16to16.c AudioLib_Play16to16_2.c AudioLib_Play24to16.c AudioLib_Play24to24.c AudioLib_Play32.c AudioLib_Play32to16.c AudioLib_Play32to32.c AudioLib_Rec.c AudioLib_Rec16.c AudioLib_Rec16_2.c AudioLib_Rec16to16.c AudioLib_Rec16to16_2.c AudioLib_Rec16to24.c AudioLib_Rec16to32.c AudioLib_Rec24to24.c AudioLib_Rec32.c AudioLib_Rec32to32.c CodecExternal.c CodecInternal.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/IAR/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Hardware
    ../Hardware/: Hardware.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c retarget.c sys.c timer.c uart.c usbd.c
  group USB
    ../USB/: descriptors_10.c descriptors_20.c UAC_ClassOUT_10.c UAC_ClassOUT_20.c UAC_ClassRequest_10.c UAC_ClassRequest_20.c UAC_Init_10.c UAC_Init_20.c UAC_SetInterface_10.c UAC_SetInterface_20.c usbd_audio_10.c usbd_audio_20.c USBD_IRQHandler_10.c USBD_IRQHandler_20.c USBLib.c
  group User
    ../: main.c
