# Keil uVision project I2S_NAU8822_WAVPLAYER_SD.uvprojx, settings and files
target I2S_NAU8822_WAVPLAYER_SD (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_NAU8822_WAVPLAYER_SD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\..\ThirdParty\FATFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\spirom_SD.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Source
    ../: main.c diskio.c wavplayer.c nuc505_isr.c SDGlue.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c sd.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
