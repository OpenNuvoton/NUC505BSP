# Keil uVision project USBD_Audio_Headset.uvprojx, settings and files
target USBD_Audio_Headset (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_Audio_Headset
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc;..\Hardware;..\Audio;..\USB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c i2c.c i2s.c usbd.c gpio.c timer.c
  group User
    ../: main.c
  group Hardware
    ../Hardware/: Hardware.c
  group Audio
    ../Audio/: AudioLib.c AudioLib_Rec.c AudioLib_Rec16.c AudioLib_Rec32.c AudioLib_Rec16_2.c AudioLib_Rec16to16.c AudioLib_Rec24to24.c AudioLib_Rec32to32.c AudioLib_Rec16to16_2.c AudioLib_Rec16to24.c AudioLib_Rec16to32.c AudioLib_Play.c AudioLib_Play16.c AudioLib_Play32.c AudioLib_Play16_2.c AudioLib_Play16to16.c AudioLib_Play24to24.c AudioLib_Play32to32.c AudioLib_Play16to16_2.c AudioLib_Play24to16.c AudioLib_Play32to16.c CodecInternal.c CodecExternal.c
  group USB
    ../USB/: USBLib.c usbd_audio_10.c usbd_audio_20.c descriptors_10.c descriptors_20.c USBD_IRQHandler_10.c USBD_IRQHandler_20.c UAC_Init_10.c UAC_Init_20.c UAC_ClassOUT_10.c UAC_ClassOUT_20.c UAC_ClassRequest_10.c UAC_ClassRequest_20.c UAC_SetInterface_10.c UAC_SetInterface_20.c
