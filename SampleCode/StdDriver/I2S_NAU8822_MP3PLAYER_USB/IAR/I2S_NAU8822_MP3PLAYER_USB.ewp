# IAR project I2S_NAU8822_MP3PLAYER_USB.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __WINS__; OPT_SPEED
  ICCARM.CCDiagSuppress: Pa082,Pe188,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FATFS\src; ..\..\..\..\ThirdParty\LibMAD\inc; ..\..\..\..\Library\UsbHostLib\INCLUDE; ..\..\..\..\Library\UsbHostLib\INCLUDE\inc_mass
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: I2S_NAU8822_MP3PLAYER_USB.bin
  ILINK.IlinkOutputFile: I2S_NAU8822_MP3PLAYER_USB.out
  ILINK.IlinkIcfFile: main_on_sram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/IAR/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group FATFS
    ../../../../ThirdParty/FATFS/src/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c i2s.c retarget.c sys.c uart.c
  group MP3
    ../../../../ThirdParty/LibMAD/src/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c MP3Func.c stream.c synth.c timer.c version.c
  group Source
    ../: diskio.c ExternalCODEC.c main.c mp3.c MP3HeaderParser.c nuc505_isr.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/SOURCE/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_MASS_Lib
    ../../../../Library/UsbHostLib/SOURCE/MassStor/: Umas_FATFS.c UmasDebug.c UmasDriver.c UmasProtocol.c UmasTransport.c
