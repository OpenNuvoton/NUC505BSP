# Keil uVision project ISP.uvprojx, settings and files
target ISP (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output "..\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c usbd.c spim.c sys.c timer.c
    ../: spiflash_drv.c
  group User
    ../: main.c descriptors.c MassStorage.c
