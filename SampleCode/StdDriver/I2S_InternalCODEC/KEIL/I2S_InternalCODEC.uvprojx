# Keil uVision project I2S_InternalCODEC.uvprojx, settings and files
target I2S_InternalCODEC (ARM-ADS)
  device: NUC505YO13Y Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_InternalCODEC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\spirom.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2s.c retarget.c sys.c uart.c
  group User
    ../: main.c nuc505_isr.c
